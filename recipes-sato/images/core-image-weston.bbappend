IMAGE_INSTALL += " mesa-driver-i965 mesa-driver-i915 mesa-driver-swrast"
IMAGE_INSTALL += " mesa-driver-vmwgfx libgbm-gallium"
IMAGE_INSTALL += " weston-setting "
