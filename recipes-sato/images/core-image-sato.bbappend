IMAGE_INSTALL += " mesa-driver-i965 mesa-driver-i915 mesa-driver-swrast"
IMAGE_INSTALL += " mesa-driver-vmwgfx "
IMAGE_INSTALL += " xf86-video-vmware "
