PACKAGECONFIG_append = " gallium gallium-egl gallium-gbm"

GALLIUMDRIVERS_append = ",svga"
